# Keil uVision project led.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: led +hex
  c flags: Optim=1
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
